# Keil uVision project 13139463.uvproj, settings and files
target 13139463 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 13139463 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\lib
  group YanPeng
    ./: STARTUP.A51 main.c key.c keyscan.c usart.c
  group Lib
    ./lib/: DS1302.c iic.c onewire.c
